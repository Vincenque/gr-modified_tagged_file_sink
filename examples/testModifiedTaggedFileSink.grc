options:
  parameters:
    generate_options: qt_gui
    id: testModifiedTaggedFileSink
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: burst
  id: variable_qtgui_push_button
  parameters:
    label: Burst
    pressed: '1'
    released: '0'
    type: bool
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(1e6)
  states: {}
- name: variable_qtgui_entry_0
  id: variable_qtgui_entry
  parameters:
    type: string
    value: test
  states: {}
- name: block_test_bursts
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, burst=False):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              
              self.burst = burst
              self.burst_state = False

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              
              if self.burst != self.burst_state:        
                  self.burst_state = self.burst
              
                  key = pmt.intern("burst")
                  value = pmt.from_bool(self.burst_state)
                  self.add_item_tag(0, self.nitems_written(0), key, value)
              
              output_items[0][:] = input_items[0] 
              return len(output_items[0])
    burst: burst
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    type: complex
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: triangle.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: modified_tagged_file_sink_module_modified_tagged_file_sink_0
  id: modified_tagged_file_sink_module_modified_tagged_file_sink
  parameters:
    append: 'False'
    file: variable_qtgui_entry_0+"1"
    samp_rate: samp_rate
    type: complex
    vlen: '1'
  states: {}
- name: modified_tagged_file_sink_module_modified_tagged_file_sink_0_0
  id: modified_tagged_file_sink_module_modified_tagged_file_sink
  parameters:
    append: 'False'
    file: variable_qtgui_entry_0+"2"
    samp_rate: samp_rate
    type: complex
    vlen: '1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: int(1e4)
    srate: samp_rate
    type: complex
  states: {}

connections:
- [block_test_bursts, '0', modified_tagged_file_sink_module_modified_tagged_file_sink_0, '0']
- [block_test_bursts, '0', modified_tagged_file_sink_module_modified_tagged_file_sink_0_0, '0']
- [block_test_bursts, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', block_test_bursts, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
